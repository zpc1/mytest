# Keil uVision project iCar.uvproj, settings and files
target iCar (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iCar
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\User;.\Drivers;.\Drivers\Fatfs;.\usb_library\inc;.\Drivers\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c iGPRS.c AutoLoop.c SysConf.c BLE.c timelength.c
  group BSP
    ./Drivers/: BSP.c INT.c USART.c CAN.c RTC.c ADC.c SIM900A.c UM220.c NRF24L01.c
  group Fatfs
    ./Drivers/FATFS/: diskio.c ff.c NorFlash.c
  group Protocol
    ./User/: ISO14230.c ISO15765.c ISO9141.c Search.c
  group StartUp
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./User/: system_stm32f10x.c
  group MPU6050
    ./Drivers/MPU6050/: mpu6050.c
